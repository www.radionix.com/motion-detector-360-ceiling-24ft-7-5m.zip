Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Project Number
Time: 2023-06-21T17:31:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 17:31:49 2023 * Host: LIS-C-00085 * Database: C:\Users\MOA2OVR\AppData\Local\Temp\{5C395825-8F00-49DE-8CB2-4DCDD2AA75C9}\ifc * Database version: 5507 * Database creation date: Wed Jun 21 17:31:46 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 17:31:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 17:31:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: Motion detector 360° ceiling 24ft (7.5m), Intrusion-Products_Bosch_Motion_Detector_360°_ceiling_24ft (7-5m)_White:Motion_Detector_360°_ceiling_24ft (7.5m):236408
In: Level 1
Type - PredefinedType: MOVEMENTSENSOR; Classification: Pr_75_80_42_16 Combined passive infrared and microwave movement detectors (Uniclass 2015); Material: Xtech_Bosch_ABS_White
Type - Constraints - Default Elevation: 2200 mm
Type - Dimensions - 2DSymbolOffset: 3 mm; Dimension height (mm): 3.5; Dimension horizontal diameter (cm): 11.7
Type - General - Detection range standard: 4m x 4m; Detector type: Panoramic PIR Detector; Operating temperature (°C) (maximum): 49; Operating temperature (°C) (minimum): 15; Operating voltage (VDC) (maximum): 10; Operating voltage (VDC) (minimum): 15
Type - Identity Data - Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; Family version: 0; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/DS936_Series_Installation_Manual_enUS_2628657547.pdf; Manufacturer: Bosch Security and Safety Systems; Material number: 4.998.800.224; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; PlanningTools: https://resources-boschsecurity-cdn.azureedge.net/public/documents/DS936_Series_Installation_Manual_enUS_2628657547.pdf; Product Description: Motion detector 360° ceiling 24ft (7.5m); Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/DS936_Series_Data_sheet_enUS_2628645131.pdf; Product Website: https://commerce.boschsecurity.com/nordics/en/DS936-Low-Profile-Panoramic-PIR-Detector/p/4.998.800.224/; Type Name: Motion_Detector_360°_ceiling_24ft (7.5m)
Type - Materials and Finishes - Color: White
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_Motion_Detector_360°_ceiling_24ft (7-5m)_White
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Volume: 0.000284118 m3
Identity Data - CTN: DS936; Mark: 26
Other - 2D_FlippedPosition: yes; 2D_OriginalPosition: no; Family: Intrusion-Products_Bosch_Motion_Detector_360°_ceiling_24ft (7-5m)_White: Motion_Detector_360°_ceiling_24ft (7.5m); Family and Type: Intrusion-Products_Bosch_Motion_Detector_360°_ceiling_24ft (7-5m)_White: Motion_Detector_360°_ceiling_24ft (7.5m); Schedule Level: Level: Level 1; Type: Intrusion-Products_Bosch_Motion_Detector_360°_ceiling_24ft (7-5m)_White: Motion_Detector_360°_ceiling_24ft (7.5m); Type Id: Intrusion-Products_Bosch_Motion_Detector_360°_ceiling_24ft (7-5m)_White: Motion_Detector_360°_ceiling_24ft (7.5m)
Phasing - Phase Created: New Construction
